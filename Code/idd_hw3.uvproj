# Keil uVision project idd_hw3.uvproj, settings and files
target mbed FRDM-KL25Z (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: idd_hw3
  AfterMake: fromelf --bin -o build\idd_hw3_KL25Z.bin build\idd_hw3.axf
  c flags: Optim=1
  c define: TARGET_FF_ARDUINO,  TARGET_KLXX,  TARGET_KL25Z,  TARGET_CORTEX_M,  TARGET_M0P,  TARGET_Freescale,  __MBED__=1,  __CORTEX_M0PLUS,  TOOLCHAIN_ARM,  TOOLCHAIN_ARM_STD,  ARM_MATH_CM0PLUS,  MBED_BUILD_TIMESTAMP=1442915709.31,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;  USBDevice;  USBDevice/USBAudio;  USBDevice/USBDevice;  USBDevice/USBHID;  USBDevice/USBMIDI;  USBDevice/USBSerial;  USBDevice/USBMSD;  MMA8451Q;  Adafruit_NeoPixel;  Adafruit_NeoPixel/Examples;  mbed;  mbed/TARGET_KL25Z;  mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD;  mbed/TARGET_KL25Z/TARGET_Freescale;  mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX;  mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z;  PinDetect_KL25Z;
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/MKL25Z4.sct
  link misc: mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/mbed_overrides.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/system_MKL25Z4.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/board.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/startup_MKL25Z4.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    Adafruit_NeoPixel/: led_strip_write_color.s PololuLedStrip.cpp
    ./: main.cpp
    USBDevice/USBAudio/: USBAudio.cpp
    USBDevice/USBDevice/: USBHAL_KL25Z.cpp USBHAL_STM32F4.cpp USBHAL_LPC17.cpp USBHAL_LPC11U.cpp USBHAL_LPC40.cpp USBDevice.cpp
    USBDevice/USBHID/: USBMouse.cpp USBKeyboard.cpp USBMouseKeyboard.cpp USBHID.cpp
    USBDevice/USBMIDI/: USBMIDI.cpp
    USBDevice/USBSerial/: USBSerial.cpp USBCDC.cpp
    USBDevice/USBMSD/: USBMSD.cpp
    MMA8451Q/: MMA8451Q.cpp
    Adafruit_NeoPixel/Examples/: LedStripGradient.cpp
